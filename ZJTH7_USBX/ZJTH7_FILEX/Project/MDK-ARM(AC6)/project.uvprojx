# Keil uVision project project.uvprojx, settings and files
target Flash (6220000::V6.22::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32H743xx, TX_ENABLE_FPU_SUPPORT, TX_ENABLE_STACK_CHECKING, TX_INCLUDE_USER_DEFINE_FILE,GX_INCLUDE_USER_DEFINE_FILE
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\BSP\inc;..\..\User;..\..\User\BSP;..\..\ThreadX\common\inc;..\..\ThreadX\ports\cortex_m7\ac6\inc;..\..\User\segger\RTT Viewer\RTT;..\..\User\fonts;..\..\NetXDUO\common\inc;..\..\NetXDUO\ports\cortex_m7;..\..\NetXDUO\ports\cortex_m7\ac5\inc;..\..\User\netx;..\..\User\threadx;..\..\usbx\ports\cortex_m7\gnu\inc;..\..\usbx\common\core\inc;..\..\usbx\common\usbx_device_classes\inc;..\..\usbx\common\usbx_host_classes\inc;..\..\usbx\common\usbx_host_controllers\inc;..\..\usbx\common\usbx_network\inc;..\..\usbx\common\usbx_pictbridge\inc;..\..\usbx\common\usbx_stm32_device_controllers;..\..\usbx\common\usbx_stm32_host_controllers;..\..\User\usbx
  asm define: TX_ENABLE_FPU_SUPPORT
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ./Ux_Host_HID.sct
  group User
    ../../User/: main.c includes.h
    ../../ThreadX/ports/cortex_m7/ac6/inc/: tx_port.h
    ../../User/threadx/: tx_user.h
    ../../usbx/ports/cortex_m7/gnu/inc/: ux_port.h
  group APP
    ../../User/usbx/: app_usbx_host.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c stm32h7xx_hal_timebase_tim.c
    ../../User/BSP/src/: bsp_key.c bsp_sdio_sd.c
    ../../User/bsp/src/: bsp_led.c bsp_dwt.c bsp_timer.c bsp_beep.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_fmc_sdram.c bsp_tft_h7.c bsp_tft_lcd.c bsp_ts_touch.c bsp_ts_ft5x06.c bsp_ts_gt811.c bsp_ts_gt911.c bsp_ts_stmpe811.c bsp_i2c_gpio.c bsp_i2c_eeprom_24xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_smbus_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT Viewer/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group ThreadX/Ports
    ../../ThreadX/ports/cortex_m7/ac6/example_build/sample_threadx/: tx_initialize_low_level.S
    ../../ThreadX/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group ThreadX/Source
    ../../ThreadX/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group USBX/Ports
    ../../User/usbx/: usb_otg.c ux_host_keyboard.c ux_host_mouse.c
  group USBX/Core/Source
    ../../usbx/common/core/src/: ux_dcd_sim_slave_address_set.c ux_dcd_sim_slave_endpoint_create.c ux_dcd_sim_slave_endpoint_destroy.c ux_dcd_sim_slave_endpoint_reset.c ux_dcd_sim_slave_endpoint_stall.c ux_dcd_sim_slave_endpoint_status.c ux_dcd_sim_slave_frame_number_get.c ux_dcd_sim_slave_function.c ux_dcd_sim_slave_initialize.c ux_dcd_sim_slave_initialize_complete.c ux_dcd_sim_slave_state_change.c ux_dcd_sim_slave_transfer_abort.c ux_dcd_sim_slave_transfer_request.c ux_dcd_sim_slave_transfer_run.c ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_read_run.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_class_dpump_write_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_hcd_sim_host_asynch_queue_process.c ux_hcd_sim_host_asynch_schedule.c ux_hcd_sim_host_asynchronous_endpoint_create.c ux_hcd_sim_host_asynchronous_endpoint_destroy.c ux_hcd_sim_host_controller_disable.c ux_hcd_sim_host_ed_obtain.c ux_hcd_sim_host_ed_td_clean.c ux_hcd_sim_host_endpoint_reset.c ux_hcd_sim_host_entry.c ux_hcd_sim_host_frame_number_get.c ux_hcd_sim_host_frame_number_set.c ux_hcd_sim_host_initialize.c ux_hcd_sim_host_interrupt_endpoint_create.c ux_hcd_sim_host_iso_queue_process.c ux_hcd_sim_host_iso_schedule.c ux_hcd_sim_host_isochronous_endpoint_create.c ux_hcd_sim_host_isochronous_td_obtain.c ux_hcd_sim_host_least_traffic_list_get.c ux_hcd_sim_host_periodic_endpoint_destroy.c ux_hcd_sim_host_periodic_schedule.c ux_hcd_sim_host_periodic_tree_create.c ux_hcd_sim_host_port_reset.c ux_hcd_sim_host_port_status_get.c ux_hcd_sim_host_regular_td_obtain.c ux_hcd_sim_host_request_bulk_transfer.c ux_hcd_sim_host_request_control_transfer.c ux_hcd_sim_host_request_interupt_transfer.c ux_hcd_sim_host_request_isochronous_transfer.c ux_hcd_sim_host_request_transfer.c ux_hcd_sim_host_timer_function.c ux_hcd_sim_host_transaction_schedule.c ux_hcd_sim_host_transfer_abort.c ux_hcd_sim_host_transfer_run.c ux_hcd_sim_host_uninitialize.c ux_host_class_dpump_activate.c ux_host_class_dpump_configure.c ux_host_class_dpump_deactivate.c ux_host_class_dpump_endpoints_get.c ux_host_class_dpump_entry.c ux_host_class_dpump_ioctl.c ux_host_class_dpump_read.c ux_host_class_dpump_write.c ux_host_stack_bandwidth_check.c ux_host_stack_bandwidth_claim.c ux_host_stack_bandwidth_release.c ux_host_stack_class_call.c ux_host_stack_class_device_scan.c ux_host_stack_class_get.c ux_host_stack_class_instance_create.c ux_host_stack_class_instance_destroy.c ux_host_stack_class_instance_get.c ux_host_stack_class_instance_verify.c ux_host_stack_class_interface_scan.c ux_host_stack_class_register.c ux_host_stack_class_unregister.c ux_host_stack_configuration_descriptor_parse.c ux_host_stack_configuration_enumerate.c ux_host_stack_configuration_instance_create.c ux_host_stack_configuration_instance_delete.c ux_host_stack_configuration_interface_get.c ux_host_stack_configuration_interface_scan.c ux_host_stack_configuration_set.c ux_host_stack_delay_ms.c ux_host_stack_device_address_set.c ux_host_stack_device_configuration_activate.c ux_host_stack_device_configuration_deactivate.c ux_host_stack_device_configuration_get.c ux_host_stack_device_configuration_reset.c ux_host_stack_device_configuration_select.c ux_host_stack_device_descriptor_read.c ux_host_stack_device_get.c ux_host_stack_device_remove.c ux_host_stack_device_resources_free.c ux_host_stack_device_string_get.c ux_host_stack_endpoint_instance_create.c ux_host_stack_endpoint_instance_delete.c ux_host_stack_endpoint_reset.c ux_host_stack_endpoint_transfer_abort.c ux_host_stack_enum_thread_entry.c ux_host_stack_hcd_register.c ux_host_stack_hcd_thread_entry.c ux_host_stack_hcd_transfer_request.c ux_host_stack_hcd_unregister.c ux_host_stack_hnp_polling_thread_entry.c ux_host_stack_initialize.c ux_host_stack_interface_endpoint_get.c ux_host_stack_interface_instance_create.c ux_host_stack_interface_instance_delete.c ux_host_stack_interface_set.c ux_host_stack_interface_setting_select.c ux_host_stack_interfaces_scan.c ux_host_stack_new_configuration_create.c ux_host_stack_new_device_create.c ux_host_stack_new_device_get.c ux_host_stack_new_endpoint_create.c ux_host_stack_new_interface_create.c ux_host_stack_rh_change_process.c ux_host_stack_rh_device_extraction.c ux_host_stack_rh_device_insertion.c ux_host_stack_role_swap.c ux_host_stack_tasks_run.c ux_host_stack_transfer_request.c ux_host_stack_transfer_request_abort.c ux_host_stack_transfer_run.c ux_host_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_trace_event_insert.c ux_trace_event_update.c ux_trace_object_register.c ux_trace_object_unregister.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group USBX/Device/Classes
    ../../usbx/common/usbx_device_classes/src/: ux_device_class_audio_activate.c ux_device_class_audio_change.c ux_device_class_audio_control_request.c ux_device_class_audio_deactivate.c ux_device_class_audio_entry.c ux_device_class_audio_feedback_get.c ux_device_class_audio_feedback_set.c ux_device_class_audio_feedback_task_function.c ux_device_class_audio_feedback_thread_entry.c ux_device_class_audio_frame_write.c ux_device_class_audio_initialize.c ux_device_class_audio_interrupt_send.c ux_device_class_audio_interrupt_task_function.c ux_device_class_audio_interrupt_thread_entry.c ux_device_class_audio_ioctl.c ux_device_class_audio_read_frame_free.c ux_device_class_audio_read_frame_get.c ux_device_class_audio_read_task_function.c ux_device_class_audio_read_thread_entry.c ux_device_class_audio_reception_start.c ux_device_class_audio_sample_read8.c ux_device_class_audio_sample_read16.c ux_device_class_audio_sample_read24.c ux_device_class_audio_sample_read32.c ux_device_class_audio_speed_get.c ux_device_class_audio_stream_get.c ux_device_class_audio_tasks_run.c ux_device_class_audio_transmission_start.c ux_device_class_audio_unitialize.c ux_device_class_audio_write_frame_commit.c ux_device_class_audio_write_frame_get.c ux_device_class_audio_write_task_function.c ux_device_class_audio_write_thread_entry.c ux_device_class_audio10_control_process.c ux_device_class_audio20_control_process.c ux_device_class_ccid_activate.c ux_device_class_ccid_auto_seq_done.c ux_device_class_ccid_auto_seq_start.c ux_device_class_ccid_control_abort.c ux_device_class_ccid_control_request.c ux_device_class_ccid_deactivate.c ux_device_class_ccid_entry.c ux_device_class_ccid_hardware_error.c ux_device_class_ccid_icc_insert.c ux_device_class_ccid_icc_remove.c ux_device_class_ccid_initialize.c ux_device_class_ccid_notify_task_run.c ux_device_class_ccid_notify_thread_entry.c ux_device_class_ccid_response.c ux_device_class_ccid_runner_task_run.c ux_device_class_ccid_runner_thread_entry.c ux_device_class_ccid_tasks_run.c ux_device_class_ccid_thread_entry.c ux_device_class_ccid_time_extension.c ux_device_class_ccid_uninitialize.c ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_ioctl.c ux_device_class_cdc_acm_read.c ux_device_class_cdc_acm_read_run.c ux_device_class_cdc_acm_tasks_run.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_write.c ux_device_class_cdc_acm_write_run.c ux_device_class_cdc_acm_write_with_callback.c ux_device_class_cdc_ecm_activate.c ux_device_class_cdc_ecm_bulkin_thread.c ux_device_class_cdc_ecm_bulkout_thread.c ux_device_class_cdc_ecm_change.c ux_device_class_cdc_ecm_control_request.c ux_device_class_cdc_ecm_deactivate.c ux_device_class_cdc_ecm_entry.c ux_device_class_cdc_ecm_initialize.c ux_device_class_cdc_ecm_interrupt_thread.c ux_device_class_cdc_ecm_uninitialize.c ux_device_class_cdc_ecm_write.c ux_device_class_dfu_activate.c ux_device_class_dfu_control_request.c ux_device_class_dfu_deactivate.c ux_device_class_dfu_entry.c ux_device_class_dfu_initialize.c ux_device_class_dfu_state_get.c ux_device_class_dfu_state_sync.c ux_device_class_dfu_tasks_run.c ux_device_class_dfu_thread.c ux_device_class_hid_activate.c ux_device_class_hid_control_request.c ux_device_class_hid_deactivate.c ux_device_class_hid_descriptor_send.c ux_device_class_hid_entry.c ux_device_class_hid_event_get.c ux_device_class_hid_event_set.c ux_device_class_hid_initialize.c ux_device_class_hid_interrupt_thread.c ux_device_class_hid_read.c ux_device_class_hid_read_run.c ux_device_class_hid_receiver_event_free.c ux_device_class_hid_receiver_event_get.c ux_device_class_hid_receiver_initialize.c ux_device_class_hid_receiver_tasks_run.c ux_device_class_hid_receiver_thread.c ux_device_class_hid_receiver_uninitialize.c ux_device_class_hid_report_get.c ux_device_class_hid_report_set.c ux_device_class_hid_tasks_run.c ux_device_class_hid_uninitialize.c ux_device_class_pima_activate.c ux_device_class_pima_control_request.c ux_device_class_pima_data.c ux_device_class_pima_deactivate.c ux_device_class_pima_device_info_send.c ux_device_class_pima_device_prop_desc_get.c ux_device_class_pima_device_prop_value_get.c ux_device_class_pima_device_prop_value_set.c ux_device_class_pima_device_reset.c ux_device_class_pima_entry.c ux_device_class_pima_event_get.c ux_device_class_pima_event_set.c ux_device_class_pima_initialize.c ux_device_class_pima_interrupt_thread.c ux_device_class_pima_object_add.c ux_device_class_pima_object_data_get.c ux_device_class_pima_object_data_send.c ux_device_class_pima_object_delete.c ux_device_class_pima_object_handles_send.c ux_device_class_pima_object_info_get.c ux_device_class_pima_object_info_send.c ux_device_class_pima_object_prop_desc_get.c ux_device_class_pima_object_prop_value_get.c ux_device_class_pima_object_prop_value_set.c ux_device_class_pima_object_props_supported_get.c ux_device_class_pima_object_references_get.c ux_device_class_pima_object_references_set.c ux_device_class_pima_objects_number_send.c ux_device_class_pima_partial_object_data_get.c ux_device_class_pima_response_send.c ux_device_class_pima_storage_format.c ux_device_class_pima_storage_id_send.c ux_device_class_pima_storage_info_get.c ux_device_class_pima_thread.c ux_device_class_printer_activate.c ux_device_class_printer_control_request.c ux_device_class_printer_deactivate.c ux_device_class_printer_entry.c ux_device_class_printer_initialize.c ux_device_class_printer_ioctl.c ux_device_class_printer_read.c ux_device_class_printer_read_run.c ux_device_class_printer_soft_reset.c ux_device_class_printer_uninitialize.c ux_device_class_printer_write.c ux_device_class_printer_write_run.c ux_device_class_rndis_activate.c ux_device_class_rndis_bulkin_thread.c ux_device_class_rndis_bulkout_thread.c ux_device_class_rndis_control_request.c ux_device_class_rndis_deactivate.c ux_device_class_rndis_entry.c ux_device_class_rndis_initialize.c ux_device_class_rndis_interrupt_thread.c ux_device_class_rndis_msg_initialize.c ux_device_class_rndis_msg_keep_alive.c ux_device_class_rndis_msg_query.c ux_device_class_rndis_msg_reset.c ux_device_class_rndis_msg_set.c ux_device_class_rndis_write.c ux_device_class_storage_activate.c ux_device_class_storage_control_request.c ux_device_class_storage_csw_send.c ux_device_class_storage_deactivate.c ux_device_class_storage_entry.c ux_device_class_storage_format.c ux_device_class_storage_get_configuration.c ux_device_class_storage_get_performance.c ux_device_class_storage_get_status_notification.c ux_device_class_storage_initialize.c ux_device_class_storage_inquiry.c ux_device_class_storage_mode_select.c ux_device_class_storage_mode_sense.c ux_device_class_storage_prevent_allow_media_removal.c ux_device_class_storage_read.c ux_device_class_storage_read_capacity.c ux_device_class_storage_read_disk_information.c ux_device_class_storage_read_dvd_structure.c ux_device_class_storage_read_format_capacity.c ux_device_class_storage_read_toc.c ux_device_class_storage_report_key.c ux_device_class_storage_request_sense.c ux_device_class_storage_start_stop.c ux_device_class_storage_synchronize_cache.c ux_device_class_storage_tasks_run.c ux_device_class_storage_test_ready.c ux_device_class_storage_thread.c ux_device_class_storage_uninitialize.c ux_device_class_storage_verify.c ux_device_class_storage_write.c ux_device_class_video_activate.c ux_device_class_video_change.c ux_device_class_video_control_request.c ux_device_class_video_deactivate.c ux_device_class_video_entry.c ux_device_class_video_initialize.c ux_device_class_video_ioctl.c ux_device_class_video_max_payload_get.c ux_device_class_video_read_payload_free.c ux_device_class_video_read_payload_get.c ux_device_class_video_read_task_function.c ux_device_class_video_read_thread_entry.c ux_device_class_video_reception_start.c ux_device_class_video_stream_get.c ux_device_class_video_tasks_run.c ux_device_class_video_transmission_start.c ux_device_class_video_uninitialize.c ux_device_class_video_write_payload_commit.c ux_device_class_video_write_payload_get.c ux_device_class_video_write_task_function.c ux_device_class_video_write_thread_entry.c
  group USBX/Device/STM32Conrtrollers
    ../../usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group USBX/Host/Classes
    ../../usbx/common/usbx_host_classes/src/: ux_host_class_asix_activate.c ux_host_class_asix_configure.c ux_host_class_asix_deactivate.c ux_host_class_asix_endpoints_get.c ux_host_class_asix_entry.c ux_host_class_asix_interrupt_notification.c ux_host_class_asix_read.c ux_host_class_asix_reception_callback.c ux_host_class_asix_setup.c ux_host_class_asix_thread.c ux_host_class_asix_transmission_callback.c ux_host_class_asix_write.c ux_host_class_audio_activate.c ux_host_class_audio_alternate_setting_locate.c ux_host_class_audio_configure.c ux_host_class_audio_control_get.c ux_host_class_audio_control_request.c ux_host_class_audio_control_value_get.c ux_host_class_audio_control_value_set.c ux_host_class_audio_deactivate.c ux_host_class_audio_descriptor_get.c ux_host_class_audio_descriptors_parse.c ux_host_class_audio_device_controls_list_get.c ux_host_class_audio_device_type_get.c ux_host_class_audio_endpoints_get.c ux_host_class_audio_entity_control_get.c ux_host_class_audio_entity_control_value_get.c ux_host_class_audio_entity_control_value_set.c ux_host_class_audio_entry.c ux_host_class_audio_feedback_get.c ux_host_class_audio_feedback_set.c ux_host_class_audio_feedback_transfer_completed.c ux_host_class_audio_interrupt_notification.c ux_host_class_audio_interrupt_start.c ux_host_class_audio_raw_sampling_parse.c ux_host_class_audio_read.c ux_host_class_audio_stop.c ux_host_class_audio_streaming_sampling_get.c ux_host_class_audio_streaming_sampling_set.c ux_host_class_audio_streaming_terminal_get.c ux_host_class_audio_transfer_request.c ux_host_class_audio_transfer_request_completed.c ux_host_class_audio_write.c ux_host_class_cdc_acm_activate.c ux_host_class_cdc_acm_capabilities_get.c ux_host_class_cdc_acm_command.c ux_host_class_cdc_acm_configure.c ux_host_class_cdc_acm_deactivate.c ux_host_class_cdc_acm_endpoints_get.c ux_host_class_cdc_acm_entry.c ux_host_class_cdc_acm_ioctl.c ux_host_class_cdc_acm_read.c ux_host_class_cdc_acm_reception_callback.c ux_host_class_cdc_acm_reception_start.c ux_host_class_cdc_acm_reception_stop.c ux_host_class_cdc_acm_transfer_request_completed.c ux_host_class_cdc_acm_transmission_callback.c ux_host_class_cdc_acm_write.c ux_host_class_cdc_acm_write_with_callback.c ux_host_class_cdc_ecm_activate.c ux_host_class_cdc_ecm_deactivate.c ux_host_class_cdc_ecm_endpoints_get.c ux_host_class_cdc_ecm_entry.c ux_host_class_cdc_ecm_interrupt_notification.c ux_host_class_cdc_ecm_mac_address_get.c ux_host_class_cdc_ecm_thread.c ux_host_class_cdc_ecm_transmission_callback.c ux_host_class_cdc_ecm_transmit_queue_clean.c ux_host_class_cdc_ecm_write.c ux_host_class_gser_activate.c ux_host_class_gser_command.c ux_host_class_gser_configure.c ux_host_class_gser_deactivate.c ux_host_class_gser_endpoints_get.c ux_host_class_gser_entry.c ux_host_class_gser_ioctl.c ux_host_class_gser_read.c ux_host_class_gser_reception_callback.c ux_host_class_gser_reception_start.c ux_host_class_gser_reception_stop.c ux_host_class_gser_write.c ux_host_class_hid_activate.c ux_host_class_hid_client_register.c ux_host_class_hid_client_search.c ux_host_class_hid_configure.c ux_host_class_hid_deactivate.c ux_host_class_hid_descriptor_parse.c ux_host_class_hid_entry.c ux_host_class_hid_field_decompress.c ux_host_class_hid_global_item_parse.c ux_host_class_hid_idle_get.c ux_host_class_hid_idle_set.c ux_host_class_hid_idle_set_run.c ux_host_class_hid_instance_clean.c ux_host_class_hid_interrupt_endpoint_search.c ux_host_class_hid_item_data_get.c ux_host_class_hid_keyboard_activate.c ux_host_class_hid_keyboard_callback.c ux_host_class_hid_keyboard_deactivate.c ux_host_class_hid_keyboard_entry.c ux_host_class_hid_keyboard_ioctl.c ux_host_class_hid_keyboard_key_get.c ux_host_class_hid_keyboard_tasks_run.c ux_host_class_hid_keyboard_thread.c ux_host_class_hid_local_item_parse.c ux_host_class_hid_main_item_parse.c ux_host_class_hid_mouse_activate.c ux_host_class_hid_mouse_buttons_get.c ux_host_class_hid_mouse_callback.c ux_host_class_hid_mouse_deactivate.c ux_host_class_hid_mouse_entry.c ux_host_class_hid_mouse_position_get.c ux_host_class_hid_mouse_wheel_get.c ux_host_class_hid_periodic_report_start.c ux_host_class_hid_periodic_report_stop.c ux_host_class_hid_remote_control_activate.c ux_host_class_hid_remote_control_callback.c ux_host_class_hid_remote_control_deactivate.c ux_host_class_hid_remote_control_entry.c ux_host_class_hid_remote_control_usage_get.c ux_host_class_hid_report_add.c ux_host_class_hid_report_callback_register.c ux_host_class_hid_report_compress.c ux_host_class_hid_report_decompress.c ux_host_class_hid_report_descriptor_get.c ux_host_class_hid_report_get.c ux_host_class_hid_report_id_get.c ux_host_class_hid_report_item_analyse.c ux_host_class_hid_report_set.c ux_host_class_hid_report_set_run.c ux_host_class_hid_resources_free.c ux_host_class_hid_tasks_run.c ux_host_class_hid_transfer_request_completed.c ux_host_class_hub_activate.c ux_host_class_hub_change_detect.c ux_host_class_hub_change_process.c ux_host_class_hub_configure.c ux_host_class_hub_deactivate.c ux_host_class_hub_descriptor_get.c ux_host_class_hub_entry.c ux_host_class_hub_feature.c ux_host_class_hub_hub_change_process.c ux_host_class_hub_interrupt_endpoint_start.c ux_host_class_hub_port_change_connection_process.c ux_host_class_hub_port_change_enable_process.c ux_host_class_hub_port_change_over_current_process.c ux_host_class_hub_port_change_process.c ux_host_class_hub_port_change_reset_process.c ux_host_class_hub_port_change_suspend_process.c ux_host_class_hub_port_reset.c ux_host_class_hub_ports_power.c ux_host_class_hub_status_get.c ux_host_class_hub_tasks_run.c ux_host_class_hub_transfer_request_completed.c ux_host_class_pima_activate.c ux_host_class_pima_command.c ux_host_class_pima_configure.c ux_host_class_pima_deactivate.c ux_host_class_pima_device_info_get.c ux_host_class_pima_device_reset.c ux_host_class_pima_endpoints_get.c ux_host_class_pima_entry.c ux_host_class_pima_notification.c ux_host_class_pima_num_objects_get.c ux_host_class_pima_object_close.c ux_host_class_pima_object_copy.c ux_host_class_pima_object_delete.c ux_host_class_pima_object_get.c ux_host_class_pima_object_handles_get.c ux_host_class_pima_object_info_get.c ux_host_class_pima_object_info_send.c ux_host_class_pima_object_move.c ux_host_class_pima_object_open.c ux_host_class_pima_object_send.c ux_host_class_pima_object_transfer_abort.c ux_host_class_pima_read.c ux_host_class_pima_request_cancel.c ux_host_class_pima_session_close.c ux_host_class_pima_session_open.c ux_host_class_pima_storage_ids_get.c ux_host_class_pima_storage_info_get.c ux_host_class_pima_thumb_get.c ux_host_class_pima_write.c ux_host_class_printer_activate.c ux_host_class_printer_configure.c ux_host_class_printer_deactivate.c ux_host_class_printer_device_id_get.c ux_host_class_printer_endpoints_get.c ux_host_class_printer_entry.c ux_host_class_printer_name_get.c ux_host_class_printer_read.c ux_host_class_printer_soft_reset.c ux_host_class_printer_status_get.c ux_host_class_printer_write.c ux_host_class_prolific_activate.c ux_host_class_prolific_command.c ux_host_class_prolific_configure.c ux_host_class_prolific_deactivate.c ux_host_class_prolific_endpoints_get.c ux_host_class_prolific_entry.c ux_host_class_prolific_ioctl.c ux_host_class_prolific_read.c ux_host_class_prolific_reception_callback.c ux_host_class_prolific_reception_start.c ux_host_class_prolific_reception_stop.c ux_host_class_prolific_setup.c ux_host_class_prolific_transfer_request_completed.c ux_host_class_prolific_write.c ux_host_class_storage_activate.c ux_host_class_storage_cbw_initialize.c ux_host_class_storage_check_run.c ux_host_class_storage_configure.c ux_host_class_storage_deactivate.c ux_host_class_storage_device_initialize.c ux_host_class_storage_device_reset.c ux_host_class_storage_device_support_check.c ux_host_class_storage_driver_entry.c ux_host_class_storage_endpoints_get.c ux_host_class_storage_entry.c ux_host_class_storage_lock.c ux_host_class_storage_max_lun_get.c ux_host_class_storage_media_capacity_get.c ux_host_class_storage_media_characteristics_get.c ux_host_class_storage_media_check.c ux_host_class_storage_media_format_capacity_get.c ux_host_class_storage_media_get.c ux_host_class_storage_media_lock.c ux_host_class_storage_media_mount.c ux_host_class_storage_media_open.c ux_host_class_storage_media_protection_check.c ux_host_class_storage_media_read.c ux_host_class_storage_media_recovery_sense_get.c ux_host_class_storage_media_write.c ux_host_class_storage_partition_read.c ux_host_class_storage_read_write_run.c ux_host_class_storage_request_sense.c ux_host_class_storage_sense_code_translate.c ux_host_class_storage_start_stop.c ux_host_class_storage_tasks_run.c ux_host_class_storage_thread_entry.c ux_host_class_storage_transport.c ux_host_class_storage_transport_bo.c ux_host_class_storage_transport_cb.c ux_host_class_storage_transport_cbi.c ux_host_class_storage_transport_run.c ux_host_class_storage_unit_ready_test.c ux_host_class_swar_activate.c ux_host_class_swar_configure.c ux_host_class_swar_deactivate.c ux_host_class_swar_endpoints_get.c ux_host_class_swar_entry.c ux_host_class_swar_ioctl.c ux_host_class_swar_read.c ux_host_class_swar_reception_callback.c ux_host_class_swar_reception_start.c ux_host_class_swar_reception_stop.c ux_host_class_swar_write.c ux_host_class_video_activate.c ux_host_class_video_alternate_setting_locate.c ux_host_class_video_channel_start.c ux_host_class_video_configure.c ux_host_class_video_control_get.c ux_host_class_video_control_list_get.c ux_host_class_video_control_request.c ux_host_class_video_control_value_get.c ux_host_class_video_control_value_set.c ux_host_class_video_deactivate.c ux_host_class_video_descriptor_get.c ux_host_class_video_endpoints_get.c ux_host_class_video_entities_parse.c ux_host_class_video_entry.c ux_host_class_video_format_data_get.c ux_host_class_video_frame_data_get.c ux_host_class_video_frame_interval_get.c ux_host_class_video_frame_parameters_set.c ux_host_class_video_input_format_get.c ux_host_class_video_input_terminal_get.c ux_host_class_video_ioctl.c ux_host_class_video_max_payload_get.c ux_host_class_video_read.c ux_host_class_video_start.c ux_host_class_video_stop.c ux_host_class_video_transfer_buffer_add.c ux_host_class_video_transfer_buffers_add.c ux_host_class_video_transfer_callback_set.c ux_host_class_video_transfer_request.c ux_host_class_video_transfer_request_callback.c ux_host_class_video_transfer_request_completed.c
  group USBX/Host/Controllers
    ../../usbx/common/usbx_host_controllers/src/: ux_hcd_ehci_asynch_td_process.c ux_hcd_ehci_asynchronous_endpoint_create.c ux_hcd_ehci_asynchronous_endpoint_destroy.c ux_hcd_ehci_controller_disable.c ux_hcd_ehci_done_queue_process.c ux_hcd_ehci_door_bell_wait.c ux_hcd_ehci_ed_clean.c ux_hcd_ehci_ed_obtain.c ux_hcd_ehci_endpoint_reset.c ux_hcd_ehci_entry.c ux_hcd_ehci_frame_number_get.c ux_hcd_ehci_frame_number_set.c ux_hcd_ehci_fsisochronous_td_obtain.c ux_hcd_ehci_fsisochronous_tds_process.c ux_hcd_ehci_hsisochronous_td_obtain.c ux_hcd_ehci_hsisochronous_tds_process.c ux_hcd_ehci_initialize.c ux_hcd_ehci_interrupt_endpoint_create.c ux_hcd_ehci_interrupt_endpoint_destroy.c ux_hcd_ehci_interrupt_handler.c ux_hcd_ehci_isochronous_endpoint_create.c ux_hcd_ehci_isochronous_endpoint_destroy.c ux_hcd_ehci_least_traffic_list_get.c ux_hcd_ehci_next_td_clean.c ux_hcd_ehci_periodic_descriptor_link.c ux_hcd_ehci_periodic_tree_create.c ux_hcd_ehci_poll_rate_entry_get.c ux_hcd_ehci_port_disable.c ux_hcd_ehci_port_reset.c ux_hcd_ehci_port_resume.c ux_hcd_ehci_port_status_get.c ux_hcd_ehci_port_suspend.c ux_hcd_ehci_power_down_port.c ux_hcd_ehci_power_on_port.c ux_hcd_ehci_power_root_hubs.c ux_hcd_ehci_register_read.c ux_hcd_ehci_register_write.c ux_hcd_ehci_regular_td_obtain.c ux_hcd_ehci_request_bulk_transfer.c ux_hcd_ehci_request_control_transfer.c ux_hcd_ehci_request_interrupt_transfer.c ux_hcd_ehci_request_isochronous_transfer.c ux_hcd_ehci_request_transfer.c ux_hcd_ehci_request_transfer_add.c ux_hcd_ehci_transfer_abort.c ux_hcd_ehci_transfer_request_process.c ux_hcd_ohci_asynchronous_endpoint_create.c ux_hcd_ohci_asynchronous_endpoint_destroy.c ux_hcd_ohci_controller_disable.c ux_hcd_ohci_done_queue_process.c ux_hcd_ohci_ed_obtain.c ux_hcd_ohci_endpoint_error_clear.c ux_hcd_ohci_endpoint_reset.c ux_hcd_ohci_entry.c ux_hcd_ohci_frame_number_get.c ux_hcd_ohci_frame_number_set.c ux_hcd_ohci_initialize.c ux_hcd_ohci_interrupt_endpoint_create.c ux_hcd_ohci_interrupt_handler.c ux_hcd_ohci_isochronous_endpoint_create.c ux_hcd_ohci_isochronous_td_obtain.c ux_hcd_ohci_least_traffic_list_get.c ux_hcd_ohci_next_td_clean.c ux_hcd_ohci_periodic_endpoint_destroy.c ux_hcd_ohci_periodic_tree_create.c ux_hcd_ohci_port_disable.c ux_hcd_ohci_port_enable.c ux_hcd_ohci_port_reset.c ux_hcd_ohci_port_resume.c ux_hcd_ohci_port_status_get.c ux_hcd_ohci_port_suspend.c ux_hcd_ohci_power_down_port.c ux_hcd_ohci_power_on_port.c ux_hcd_ohci_power_root_hubs.c ux_hcd_ohci_register_read.c ux_hcd_ohci_register_write.c ux_hcd_ohci_regular_td_obtain.c ux_hcd_ohci_request_bulk_transfer.c ux_hcd_ohci_request_control_transfer.c ux_hcd_ohci_request_interupt_transfer.c ux_hcd_ohci_request_isochronous_transfer.c ux_hcd_ohci_request_transfer.c ux_hcd_ohci_transfer_abort.c ux_hcd_ohci_transfer_request_process.c
  group USBX/Host/STM32Controllers
    ../../usbx/common/usbx_stm32_host_controllers/: ux_hcd_stm32_callback.c ux_hcd_stm32_controller_disable.c ux_hcd_stm32_ed_obtain.c ux_hcd_stm32_endpoint_create.c ux_hcd_stm32_endpoint_destroy.c ux_hcd_stm32_endpoint_reset.c ux_hcd_stm32_entry.c ux_hcd_stm32_frame_number_get.c ux_hcd_stm32_initialize.c ux_hcd_stm32_interrupt_handler.c ux_hcd_stm32_least_traffic_list_get.c ux_hcd_stm32_periodic_schedule.c ux_hcd_stm32_port_disable.c ux_hcd_stm32_port_enable.c ux_hcd_stm32_port_reset.c ux_hcd_stm32_port_resume.c ux_hcd_stm32_port_status_get.c ux_hcd_stm32_port_suspend.c ux_hcd_stm32_power_down_port.c ux_hcd_stm32_power_on_port.c ux_hcd_stm32_request_bulk_transfer.c ux_hcd_stm32_request_control_transfer.c ux_hcd_stm32_request_periodic_transfer.c ux_hcd_stm32_request_trans_finish.c ux_hcd_stm32_request_trans_prepare.c ux_hcd_stm32_request_transfer.c ux_hcd_stm32_transfer_abort.c
  group USBX/PicBridge
    ../../usbx/common/usbx_pictbridge/src/: ux_pictbridge_array_element_to_array_hexa.c ux_pictbridge_data.c ux_pictbridge_dpsclient_api_abortjob.c ux_pictbridge_dpsclient_api_capability.c ux_pictbridge_dpsclient_api_configure_print_service.c ux_pictbridge_dpsclient_api_continuejob.c ux_pictbridge_dpsclient_api_device_status.c ux_pictbridge_dpsclient_api_startjob.c ux_pictbridge_dpsclient_input_object_abortjob.c ux_pictbridge_dpsclient_input_object_configure_print_service.c ux_pictbridge_dpsclient_input_object_continuejob.c ux_pictbridge_dpsclient_input_object_get_capability.c ux_pictbridge_dpsclient_input_object_prepare.c ux_pictbridge_dpsclient_input_object_startjob.c ux_pictbridge_dpsclient_object_data_get.c ux_pictbridge_dpsclient_object_data_send.c ux_pictbridge_dpsclient_object_delete.c ux_pictbridge_dpsclient_object_handles_get.c ux_pictbridge_dpsclient_object_info_get.c ux_pictbridge_dpsclient_object_info_send.c ux_pictbridge_dpsclient_object_number_get.c ux_pictbridge_dpsclient_register_event_callback_function.c ux_pictbridge_dpsclient_start.c ux_pictbridge_dpsclient_thread.c ux_pictbridge_dpshost_input_object_notify_device_status.c ux_pictbridge_dpshost_input_object_notify_job_status.c ux_pictbridge_dpshost_input_object_send.c ux_pictbridge_dpshost_notification_callback.c ux_pictbridge_dpshost_object_get.c ux_pictbridge_dpshost_output_object_configure_print_service.c ux_pictbridge_dpshost_output_object_create.c ux_pictbridge_dpshost_output_object_get_capability.c ux_pictbridge_dpshost_output_object_get_device_status.c ux_pictbridge_dpshost_response_get.c ux_pictbridge_dpshost_start.c ux_pictbridge_dpshost_startjob.c ux_pictbridge_dpshost_thread.c ux_pictbridge_element_to_decimal.c ux_pictbridge_element_to_hexa.c ux_pictbridge_hexa_to_decimal_string.c ux_pictbridge_hexa_to_element.c ux_pictbridge_hexa_to_major_minor.c ux_pictbridge_object_parse.c ux_pictbridge_output_object_tag_line_add.c ux_pictbridge_tag_name_get.c ux_pictbridge_tag_name_scan.c ux_pictbridge_xml_function_input_getcapability_capability_layouts.c ux_pictbridge_xml_function_input_getcapability_capability_papertypes.c ux_pictbridge_xml_function_input_notifydevicestatus_capabilitychanged.c ux_pictbridge_xml_function_input_notifydevicestatus_disconnectenable.c ux_pictbridge_xml_function_input_notifydevicestatus_dpsprintservicestatus.c ux_pictbridge_xml_function_input_notifydevicestatus_errorreason.c ux_pictbridge_xml_function_input_notifydevicestatus_errorstatus.c ux_pictbridge_xml_function_input_notifydevicestatus_jobendreason.c ux_pictbridge_xml_function_input_notifydevicestatus_newjobok.c ux_pictbridge_xml_function_input_startjob.c ux_pictbridge_xml_function_input_startjob_jobconfig_cropping.c ux_pictbridge_xml_function_input_startjob_jobconfig_dateprint.c ux_pictbridge_xml_function_input_startjob_jobconfig_filenameprint.c ux_pictbridge_xml_function_input_startjob_jobconfig_filetype.c ux_pictbridge_xml_function_input_startjob_jobconfig_fixedsize.c ux_pictbridge_xml_function_input_startjob_jobconfig_imageoptimize.c ux_pictbridge_xml_function_input_startjob_jobconfig_layout.c ux_pictbridge_xml_function_input_startjob_jobconfig_papersize.c ux_pictbridge_xml_function_input_startjob_jobconfig_papertype.c ux_pictbridge_xml_function_input_startjob_jobconfig_quality.c ux_pictbridge_xml_function_input_startjob_printinfo.c ux_pictbridge_xml_function_input_startjob_printinfo_copies.c ux_pictbridge_xml_function_input_startjob_printinfo_copyid.c ux_pictbridge_xml_function_input_startjob_printinfo_croppingarea.c ux_pictbridge_xml_function_input_startjob_printinfo_date.c ux_pictbridge_xml_function_input_startjob_printinfo_fileid.c ux_pictbridge_xml_function_input_startjob_printinfo_filename.c ux_pictbridge_xml_function_input_startjob_printinfo_filepath.c ux_pictbridge_xml_function_input_startjob_printinfo_prtid.c ux_pictbridge_xml_function_null.c ux_pictbridge_xml_function_output_getcapability_capability_croppings.c ux_pictbridge_xml_function_output_getcapability_capability_dateprints.c ux_pictbridge_xml_function_output_getcapability_capability_filenameprints.c ux_pictbridge_xml_function_output_getcapability_capability_filetypes.c ux_pictbridge_xml_function_output_getcapability_capability_fixedsizes.c ux_pictbridge_xml_function_output_getcapability_capability_imageoptimizes.c ux_pictbridge_xml_function_output_getcapability_capability_layouts.c ux_pictbridge_xml_function_output_getcapability_capability_papersizes.c ux_pictbridge_xml_function_output_getcapability_capability_papertypes.c ux_pictbridge_xml_function_output_getcapability_capability_qualities.c ux_pictbridge_xml_function_output_getdevicestatus_capabilitychanged.c ux_pictbridge_xml_function_output_getdevicestatus_disconnectenable.c ux_pictbridge_xml_function_output_getdevicestatus_dpsprintservicestatus.c ux_pictbridge_xml_function_output_getdevicestatus_errorreason.c ux_pictbridge_xml_function_output_getdevicestatus_errorstatus.c ux_pictbridge_xml_function_output_getdevicestatus_jobendreason.c ux_pictbridge_xml_function_output_getdevicestatus_newjobok.c ux_pictbridge_xml_function_output_result.c ux_pictbridge_xml_function_root_dps.c ux_pictbridge_xml_function_root_input.c ux_pictbridge_xml_function_root_output.c ux_pictbridge_xml_function_root_xml.c
  group USBX/Network
    ../../usbx/common/usbx_network/src/: ux_network_driver.c
